# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L053C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32L053xx
  c misc: --C99
  c include: ..\src\hal_driver\Inc;..\src\hal_driver\Inc\Legacy;..\src\perpherial\Inc;..\src\user\bootloader;..\src\xmodem;..\src\Radio
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group hal_driver
    ../src/hal_driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_dma.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c
  group utility
    ../src/perpherial/Src/: clock.c uart.c jump.c stm32l0538_discovery.c stop.c flash.c flash_ram.c crc.c
  group main
    ../src/user/bootloader/: boot_main.c stm32l0xx_hal_msp.c stm32l0xx_it.c system_stm32l0xx.c
    ../src/user/: startup_stm32l053xx.s
  group ota
    ../src/xmodem/: xmodem.c ota.c
software components: CMSIS:CORE 5.0.0
