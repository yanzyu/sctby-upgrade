# Keil uVision project application.uvprojx, settings and files
target application (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L053C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: application +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32L053xx
  c misc: --C99
  c include: ..\src\hal_driver\Inc;..\src\hal_driver\Inc\Legacy;..\src\perpherial\Inc;..\src\appConfig;..\module;..\src\user\application
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\src\appConfig\bootScatter.sct
  link misc: --diag_suppress=L6329
  group hal_driver
    ../src/hal_driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c
  group utility
    ../src/perpherial/Src/: clock.c stop.c uart.c jump.c
  group main
    ../src/user/application/: app_main.c stm32l0xx_hal_msp.c stm32l0xx_it.c system_stm32l0xx.c
    ../src/user/: startup_stm32l053xx.s
  group appConfig
    ../src/appConfig/: appConfig.c appConfig.h
  group module
    ../module/: led.c bsw.c
software components: CMSIS:CORE 5.0.0
